# IAR project RTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GE6PM TexasInstruments TM4C123GE6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: RTOS.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: croutine.h cstartup_M.c deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h heap_2.c list.c list.h main.c mpu_prototypes.h mpu_wrappers.h port.c portable.h portasm.s portmacro.h projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.h TM4C123GH6PM.h uart.c uart.h

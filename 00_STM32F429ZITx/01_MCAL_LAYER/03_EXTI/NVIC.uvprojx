# Keil uVision project NVIC.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RCC_driver
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SRC
    ./: EXTI.c main.c
    ../01_GPIO/: GPIO.c
    ../02_NVIC/: NVIC.c
  group INC
    ../../00_LIBRARY_LAYER/00_STD_TYPES/: STD_TYPES.h
    ./: EXTI_Cfg.h EXTI_Private.h EXTI.h RCC.h RCC_CONFIG.h
    ../01_GPIO/: GPIO.h GPIO_Cfg.h GPIO_Priv.h
    ../02_NVIC/: NVIC.h NVIC_Cfg.h NVIC_Private.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3

# Keil uVision project SPI.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c
  group MCAL_SRC
    ./: SPI.c
    ../01_GPIO/: GPIO.c
    ../00_RCC/: RCC.c
  group MCAL_INC
    ./: SPI_private.h SPI.h
    ../../00_LIBRARY_LAYER/00_STD_TYPES/: STD_TYPES.h
    ../01_GPIO/: GPIO.h GPIO_Cfg.h GPIO_Priv.h
    ../00_RCC/: RCC.h RCC_CONFIG.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
